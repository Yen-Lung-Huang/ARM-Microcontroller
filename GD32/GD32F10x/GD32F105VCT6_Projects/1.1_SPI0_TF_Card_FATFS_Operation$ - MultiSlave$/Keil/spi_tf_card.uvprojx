# Keil uVision project spi_tf_card.uvprojx, settings and files
target GD32F105VCT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F105VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: spi_tf_card
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\inc;..\..\..\Firmware\CMSIS;..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c systick.c gd32f10x_it.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Soft_Drive
    ../src/: spi_sd.c
  group FATFS
    ../fat_fs/src/: diskio.c fattime.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: 00readme.txt readme.txt
