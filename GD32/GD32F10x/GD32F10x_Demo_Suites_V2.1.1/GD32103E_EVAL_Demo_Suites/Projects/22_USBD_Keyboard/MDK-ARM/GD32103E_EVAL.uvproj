# Keil uVision project GD32103E_EVAL.uvproj, settings and files
target GD32103E_EVAL (ARM-ADS)
  device: GD32F103ZE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\hid\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\device\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\usbd\Include;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../src/: main.c gd32f10x_it.c gd32f10x_usbd_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group GD32F10x_EVAL
    ../../../Utilities/: gd32f103e_eval.c
  group USBD_Drivers
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
