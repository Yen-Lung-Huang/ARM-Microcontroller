# IAR project GD32105C_EVAL.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F105xC GD GD32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\host\class\msc\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\host\core\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\class\msc; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f10x_it.c gd32f10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f105c_eval.c
    ../src/: gd32f105c_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F10x_Peripherals
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Class
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
