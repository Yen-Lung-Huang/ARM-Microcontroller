# IAR project GD32103B_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xB GD GD32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_MD
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\GD32F10x_Firmware_Library\CMSIS; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\Utilities; ..\Soft_Drive; ..\..\..\Utilities\LCD_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32103B_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f10x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../Utilities/: gd32f103b_eval.c gd32f103b_lcd_eval.c
    ../../../Utilities/LCD_common/: lcd_font.c
  group GD32F10x_Peripherals
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_md.s
