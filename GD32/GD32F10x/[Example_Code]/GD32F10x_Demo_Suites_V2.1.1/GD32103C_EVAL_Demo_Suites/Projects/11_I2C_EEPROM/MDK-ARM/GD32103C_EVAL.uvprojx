# Keil uVision project GD32103C_EVAL.uvprojx, settings and files
target GD32F103C_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\;..\Soft_Drive;..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\..\..\GD32F10x_Firmware_Library\CMSIS;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: main.c gd32f10x_it.c systick.c
  group CMSIS
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F10x_EVAL
    ../../../Utilities/: gd32f103c_eval.c
  group Soft_Drive
    ../Soft_Drive/: at24cxx.c i2c.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
