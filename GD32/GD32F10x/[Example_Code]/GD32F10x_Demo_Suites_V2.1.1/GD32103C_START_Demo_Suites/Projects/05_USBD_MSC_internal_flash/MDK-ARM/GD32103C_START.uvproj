# Keil uVision project GD32103C_START.uvproj, settings and files
target USBD_MSC (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MSC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\usbd\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\device\Include;..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\msc\Include;..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../src/: gd32f10x_it.c main.c gd32f10x_usbd_hw.c internal_flash_if.c msc_mem.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_usart.c
  group GD32F10x_START
    ../../../Utilities/: gd32f103c_start.c
  group USBD_Drivers
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/class/device/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
