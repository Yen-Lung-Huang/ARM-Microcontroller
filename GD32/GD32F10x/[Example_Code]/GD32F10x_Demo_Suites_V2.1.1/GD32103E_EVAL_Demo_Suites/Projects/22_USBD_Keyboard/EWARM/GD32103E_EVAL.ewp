# IAR project GD32103E_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xE GD GD32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\Utilities; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\class\device\hid\Include; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\device\Include; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_library\usbd\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_keyboard.srec
  ILINK.IlinkOutputFile: HID_Keyboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f10x_it.c gd32f10x_usbd_hw.c hid_keyboard_itf.c main.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../Utilities/: gd32f103e_eval.c
  group GD32F10x_Peripherals
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_hd.s
  group USB_Drivers
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Class
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group USBD_Device
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
