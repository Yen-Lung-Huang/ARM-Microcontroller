# IAR project GD32107C_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS; ..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\Third_party\lwip-2.1.2\src\include; ..\..\..\Third_party\lwip-2.1.2\port\GD32F10x; ..\..\..\Third_party\lwip-2.1.2\port\GD32F10x\FreeRTOS; ..\..\..\Third_party\FreeRTOSv10.3.1\FreeRTOS\Source\include; ..\..\..\Third_party\FreeRTOSv10.3.1\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: GD32107C_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F107xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f10x_enet_eval.c gd32f10x_it.c hello_gigadevice.c main.c netconf.c tcp_client.c udp_echo.c
  group CMSIS
    ../../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f107c_eval.c
  group GD32F10x_Peripherals
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32F10x/FreeRTOS/: ethernetif.c sys_arch.c
  group Startup
    ../../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
