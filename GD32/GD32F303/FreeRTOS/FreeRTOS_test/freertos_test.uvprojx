# Keil uVision project freertos_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
