# Keil uVision project freertos_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F105VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos_test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group FreeRTOS
    ./FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.1
