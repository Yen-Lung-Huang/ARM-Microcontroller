# Keil uVision project GD32105R_START.uvproj, settings and files
target USBFS_MSC_HOST (ARM-ADS)
  device: GD32F105RC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F10X_CL
  c include: ..\inc;..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\driver\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\host\class\msc\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\host\core\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\class\msc;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\common;..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c gd32f10x_it.c usbh_usr.c gd32f10x_usb_hw.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group GD32F10x_START
    ../../../../Utilities/: gd32f105r_start.c
  group USB_Drivers
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Startup
    ../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: readme.txt
