# Keil uVision project GD32107C_EVAL.uvproj, settings and files
target GD32107C_EVAL (ARM-ADS)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GD32107C_EVAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\inc;..\..\..\Third_party\FreeRTOSv10.3.1\FreeRTOS\Source\include;..\..\..\Third_party\FreeRTOSv10.3.1\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Third_party\lwip-2.1.2\src\include;..\..\..\Third_party\lwip-2.1.2\port\GD32F10x\FreeRTOS;..\..\..\Third_party\lwip-2.1.2\port\GD32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c tcp_client.c udp_echo.c gd32f10x_enet_eval.c gd32f10x_it.c
  group CMSIS
    ../../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f107c_eval.c
  group Lwip
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32F10x/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Startup
    ../../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: readme.txt
