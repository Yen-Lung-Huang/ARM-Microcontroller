# Keil uVision project Basic_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MG32F02U128 Megawin
  pack: Megawin.CM0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x3800) IRAM2(0x20003800,0x800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Basic_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3800
  memory RVCT10: RAM 0x20003800 size 0x800
  group Source Group 1
    ./: main.c Sample_TM00_Delay.c
software components: CMSIS:CORE 5.4.0, ChipInit_Wizard:CSC 1.0.4, ChipInit_Wizard:GPIO 1.0.0, ChipInit_Wizard:IRQ handler 1.0.5, Device:Startup 1.0.4, Driver:Driver-All 1.0.1
