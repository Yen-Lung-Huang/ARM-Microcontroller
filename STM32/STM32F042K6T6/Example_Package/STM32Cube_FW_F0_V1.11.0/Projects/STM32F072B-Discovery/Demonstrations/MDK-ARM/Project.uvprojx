# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery_Demo (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32F072B-Discovery;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\ST\STM32_TouchSensing_Library\inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Middlewares/STM32_USBD_Library/Class
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Demo/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_time.c tsl_object.c tsl_ecs.c tsl.c tsl_filter.c tsl_dxs.c tsl_touchkey.c tsl_globals.c tsl_acq.c tsl_acq_tsc.c tsl_linrot.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tsc.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_ll_usb.c
  group Demo/User
    ../Src/: tsl_user.c usbd_conf.c main.c stm32f0xx_it.c usbd_desc.c stm32f0xx_hal_msp.c
  group Drivers/BSP/STM32F072B-Discovery
    ../../../../Drivers/BSP/STM32F072B-Discovery/: stm32f072b_discovery_gyroscope.c stm32f072b_discovery.c
    ../../../../Drivers/BSP/Components/i3g4250d/: i3g4250d.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
software components: CMSIS:CORE 4.1.0
