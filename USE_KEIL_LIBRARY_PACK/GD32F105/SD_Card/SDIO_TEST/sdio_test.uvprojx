# Keil uVision project sdio_test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F105VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdio_test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\SDIO_TEST;..\fat_fs\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
  group Fatfs
    ../fat_fs/src/: diskio.c fattime.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.5.0, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:SDIO 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
