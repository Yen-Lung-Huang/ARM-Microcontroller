# Keil uVision project gd32f303_first_try.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f303_first_try
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\my_lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./led/: gd32f30x_it.c gd32f30x_it.h gd32f30x_libopt.h main.c systick.c systick.h
    ./: gd32f303c_eval.h
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, Device:EVAL:GD32F30x 1.0.2, Device:GD32F30x_StdPeripherals:EXTI 1.0.2, Device:GD32F30x_StdPeripherals:GPIO 1.0.2, Device:GD32F30x_StdPeripherals:MISC 1.0.2, Device:GD32F30x_StdPeripherals:PMU 1.0.2, Device:GD32F30x_StdPeripherals:RCU 1.0.2, Device:GD32F30x_StdPeripherals:USART 1.0.2, Device:GD32F30x_libopt 1.0.2, Device:Startup 1.0.2
