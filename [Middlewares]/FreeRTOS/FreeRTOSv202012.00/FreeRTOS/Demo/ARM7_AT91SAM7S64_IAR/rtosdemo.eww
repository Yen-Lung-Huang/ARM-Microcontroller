<<<<<<< HEAD
<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rtosdemo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


=======
<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rtosdemo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


>>>>>>> 16c66438 (Upload from PC.)
