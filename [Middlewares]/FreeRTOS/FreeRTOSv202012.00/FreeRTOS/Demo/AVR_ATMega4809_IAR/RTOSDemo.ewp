# IAR project RTOSDemo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-arch4-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x100
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m4809 ATmega4809
  ICCAVR.CCDefines: __mega4809__; F_CPU=10000000
  ICCAVR.newCCIncludePaths: ..\..\Source; ..\..\Source\include; ..\..\Source\portable\IAR\AVR_Mega0; ..\..\Source\portable\MemMang; $PROJ_DIR$; ..\Common\include
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm4809.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.LCNearHeapSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: clk_config.h FreeRTOSConfig.h main.c main_blinky.c main_full.c main_minimal.c regtest.c regtest.h
  group Common/Full
    ../Common/Full/: print.c semtest.c
  group Common/include
    ../Common/include/: comtest.h crflash.h integer.h PollQ.h print.h recmutex.h semtest.h TaskNotify.h
  group Common/Minimal
    ../Common/Minimal/: comtest.c crflash.c integer.c PollQ.c recmutex.c TaskNotify.c
  group ParTest
    ParTest/: ParTest.c
  group protected_io
    protected_io/: ccp.h protected_io.h protected_io.S
  group serial
    serial/: interrupts.s90 serial.c
  group Source
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Source/include
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Source/portable/IAR/AVR_Mega0
    ../../Source/portable/IAR/AVR_Mega0/: port.c porthardware.h portmacro.h portmacro.s90
  group Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_1.c
