# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo_GCC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  group System
    ./: system.c startup_ARMCM4.S
  group main_and_config
    ../: main.c FreeRTOSConfig.h
  group FreeRTOS_Source
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../Source/portable/MemMang/: heap_4.c
    ../../../Source/portable/GCC/ARM_CM4F/: port.c
  group main_low_power
    ../main_low_power/: main_low_power.c low_power_tick_config.c
  group main_full
    ../main_full/: main_full.c IntQueueTimer.c
    ./: RegTest.c
    ../../Common/Minimal/: flop.c EventGroupsDemo.c TaskNotify.c blocktim.c dynamic.c GenQTest.c TimerDemo.c IntQueue.c countsem.c semtest.c death.c StaticAllocation.c
  group peripheral_library
    ../peripheral_library/basic_timer/: btimer_api.c btimer_perphl.c
