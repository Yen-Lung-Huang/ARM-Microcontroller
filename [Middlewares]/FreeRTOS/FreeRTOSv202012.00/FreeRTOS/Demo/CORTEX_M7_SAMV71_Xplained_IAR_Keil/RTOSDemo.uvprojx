# Keil uVision project RTOSDemo.uvprojx, settings and files
target SRAM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.3.0
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __SAMV71Q21__, NDEBUG
  c include: .\;.\libchip_samv7\include\cmsis\CMSIS;.\libboard_samv7-ek;.\libchip_samv7;.\libboard_samv7-ek\include;.\libchip_samv7\include\samv7;..\..\Source\include;..\RTOSDemo;..\..\Source\portable\RVDS\ARM_CM7\r0p1;..\Common\include;.\Full_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x4000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: .\libboard_samv7-ek\resources\mdk\sram.sct
  group Atmel_Libboard
    ./libboard_samv7-ek/source/: board_lowlevel.c led.c dbg_console.c
    ./libboard_samv7-ek/resources/mdk/: startup_sam.c workaround.s
    ./libboard_samv7-ek/resources/: system_sam.c
  group Source
    ./: main.c FreeRTOSConfig.h
    ./Full_Demo/: main_full.c RegTest.c IntQueueTimer.c
    ./Blinky_Demo/: main_blinky.c
  group Atmel_Libchip
    ./libchip_samv7/source/: pio.c pmc.c tc.c wdt.c supc.c pio_capture.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Common_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c IntQueue.c IntSemTest.c
software components: CMSIS:CORE 4.3.0
