# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo_GCC_MPU (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  group System
    ./: system.c startup_ARMCM4.S
  group main_and_config
    ../: main.c FreeRTOSConfig.h
    ./: RegTest.c
  group FreeRTOS_Source
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../../Source/portable/MemMang/: heap_4.c
    ../../../Source/portable/Common/: mpu_wrappers.c
    ../../../Source/portable/GCC/ARM_CM4_MPU/: port.c
  group peripheral_library
    ../peripheral_library/basic_timer/: btimer_api.c btimer_perphl.c
    ../peripheral_library/interrupt/: interrupt_api.c interrupt_ecia_perphl.c interrupt_nvic_perphl.c
    ../peripheral_library/pcr/: pcr_api.c pcr_perphl.c
    ../peripheral_library/: system_internal.c
