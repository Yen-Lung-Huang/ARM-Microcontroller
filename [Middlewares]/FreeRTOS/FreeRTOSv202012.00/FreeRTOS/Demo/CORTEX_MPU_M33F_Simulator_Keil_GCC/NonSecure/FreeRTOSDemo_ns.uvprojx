# Keil uVision project FreeRTOSDemo_ns.uvprojx, settings and files
target FVP Simulation Model (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo_ns
  c flags: Optim=2 v6Lang=3 v6LangP=1
  c include: ..\Config;..\..\Common\ARMv8M\tz_demo;..\..\Common\ARMv8M\mpu_demo;..\..\..\Source\include;..\..\..\Source\portable\GCC\ARM_CM33\secure;..\..\..\Source\portable\GCC\ARM_CM33\non_secure
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\FreeRTOSDemo_ns.sct
  group CMSE Library
    ../Secure/Objects/: FreeRTOSDemo_s_CMSE_Lib.o
  group FreeRTOS
    ../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Source/portable/MemMang/: heap_4.c
    ../../../Source/portable/Common/: mpu_wrappers.c
    ../../../Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.h portmacro.h portasm.c
  group Config
    ../Config/: FreeRTOSConfig.h
  group Demos
    ../../Common/ARMv8M/mpu_demo/: mpu_demo.h mpu_demo.c
    ../../Common/ARMv8M/tz_demo/: tz_demo.h tz_demo.c
  group User
    ./: main_ns.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.1.0
