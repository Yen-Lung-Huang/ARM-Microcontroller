<<<<<<< HEAD
<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RTOSDemo.ewp</path>
    </project>
    <batchBuild />
</workspace>
=======
<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RTOSDemo.ewp</path>
    </project>
    <batchBuild />
</workspace>
>>>>>>> 16c66438 (Upload from PC.)
